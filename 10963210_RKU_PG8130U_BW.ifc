Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2019-04-02T07:49:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170419_0315(x64) - Exporter 17.0.1128.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 02 07:49:18 2019 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{2AE0C6EA-F8A9-4D13-8F38-8DDD42391DAC}\ifc * Database version: 5507 * Database creation date: Tue Apr 02 07:49:15 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 02 07:49:16 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 02 07:49:16 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 61813006_RKU_10963210_PG8130U_BW, 10963210_RKU_PG8130U_BW:61813006_RKU_10963210_PG8130U_BW:205925
In: Level 1
Type - Material: z_Miele_Design_BRWS, z_Miele_Connection_Electric, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, z_Miele_Connection_Liquid Detergent, Polypropylene, z_Miele_Design_OBSW
Pset_BuildingElementProxyCommon - Reference: 61813006_RKU_10963210_PG8130U_BW
